# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\WDG;..\HARDWARE;..\HARDWARE\STMFLASH;..\HARDWARE\ID;..\HARDWARE\CRC16;..\HARDWARE\INCLUDE;..\HARDWARE\BARRIER;..\HARDWARE\BACK;..\HARDWARE\VOICE;..\HARDWARE\PWM;..\HARDWARE\MOTIONCONTROL;..\HARDWARE\FM24Cxx;..\HARDWARE\TIME5;..\HARDWARE\WIRELESS;..\HARDWARE\ROUTEMSG;..\HARDWARE\HMI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/ID/: id.c
    ../HARDWARE/CRC16/: CRC16.c
    ../HARDWARE/BARRIER/: barrier.c
    ../HARDWARE/BACK/: back.c
    ../HARDWARE/VOICE/: voice.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/MOTIONCONTROL/: motioncontrol.c
    ../HARDWARE/FM24Cxx/: 24cxx.c iic.c
    ../HARDWARE/TIME5/: time5.c
    ../HARDWARE/WIRELESS/: wireless.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/ROUTEMSG/: routemsg.c
    ../HARDWARE/HMI/: hmi.c
